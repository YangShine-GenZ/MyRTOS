# Keil uVision project MyRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MyRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source;.\Event
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Kernel
    ./Source/: main.c switch.c tinyOS.h time.c time.h primask.c primask.h tconfig.h common.h state.h state.c stimer.c stimer.h
    ../YangRTOS/Source/: tnode.c tbitmap.c tlib.h
  group Event
    ./Event/: block.c block.h event.c event.h eventModule.h mail.c mail.h mutex.c mutex.h sem.c sem.h tflag.c tflag.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
